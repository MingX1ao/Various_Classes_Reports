# Keil uVision project homework_2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: homework_2_4 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: homework_2_1.a51 homework_2_2.a51 homework_2_3.a51 homework_2_4.a51
