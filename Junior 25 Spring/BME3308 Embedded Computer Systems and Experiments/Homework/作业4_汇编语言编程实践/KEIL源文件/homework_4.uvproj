# Keil uVision project homework_4.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: homework_4_1_3
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 4
    ./: homework_4_3_2.a51
target Target 2 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: homework_4_3_2 +hex
  c flags: Optimize=8 SizeSpeed=1
