ORG 	0000H
LJMP	START

ORG		0003H
LJMP	ITR0

ORG		0040H
START:
		MOV		TMOD,	#00101001B
		SETB	TR0
		SETB	EA
		SETB	EX0
		SETB	IT0
		MOV		TH0,	#0H
		MOV		TL0,	#0H
		MOV		SCON,	#01010000B
		MOV		TH1,	#0FDH
		MOV		TL1,	#0FDH
		SETB	TR1
		
		SJMP	$
		
		
COMMUNITY:
		PUSH	ACC
		MOV		A,		R1
		MOV		30H,	A
		MOV		SBUF,	A
		JNB		TI,		$
		CLR		TI
		MOV		A,		R2
		MOV		31H,	A
		MOV		SBUF,	A
		JNB		TI,		$
		CLR		TI
		POP		ACC
		RET

ITR0:	
		CLR		TR0
		MOV		R1,		TH0
		MOV		R2,		TL0
		MOV		TH0,	#0H
		MOV		TL0,	#0H
		LCALL	COMMUNITY
		SETB	TR0
		RETI
		
END