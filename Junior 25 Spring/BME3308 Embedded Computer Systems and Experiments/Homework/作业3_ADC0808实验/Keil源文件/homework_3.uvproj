# Keil uVision project homework_3.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: homework_3_4_2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: homework_3_1.a51
  group Source Group 2
    ./: homework_3_3.a51
  group Source Group 3
    ./: homework_3_4.a51
  group Source Group 4
    ./: homework_3_4_2.a51
